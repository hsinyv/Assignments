# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: test +hex
  AfterMake: fromelf --bin -o @p.bin @p.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --wchar32
  c include: ..\v5test
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT6: RAM 0x31000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source Group 1
    ./: S3C2440.s main.c
