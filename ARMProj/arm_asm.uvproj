# Keil uVision project arm_asm.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: arm_asm
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source Group 1
    ./: test.s
